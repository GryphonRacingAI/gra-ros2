Commit message: Updated mppi track,  made ads_dv  dummy root to have no inertial properties

File: simulation/models/tracks/mppi_track.xacro (robot description, xacro)
@@ -29,4 +29,6 @@
       <xacro:cone name="yellow_5" type="yellow" pose="15.42825682187192 45.1678836632065 0.15 0 0 0"/>
       <xacro:cone name="yellow_6" type="yellow" pose="17.4261580674119 45.21164310790759 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_6_1" type="yellow" pose="19.4248739391 45.2260233683 0.1500000000 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_6_2" type="yellow" pose="21.4235898107 45.2404036288 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_7" type="yellow" pose="23.422305682344838 45.254783889188744 0.15 0 0 0"/>
       <xacro:cone name="yellow_8" type="yellow" pose="25.42139952249002 45.22993657457432 0.15 0 0 0"/>
@@ -36,10 +38,13 @@
       <xacro:cone name="yellow_12" type="yellow" pose="33.47581454761413 44.80762296917897 0.15 0 0 0"/>
       <xacro:cone name="yellow_13" type="yellow" pose="35.50297905015566 44.49067883038596 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_13_1" type="yellow" pose="37.4509538177 43.8497091944 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_14" type="yellow" pose="39.39892858533195 43.20873955836343 0.15 0 0 0"/>
       <xacro:cone name="yellow_15" type="yellow" pose="41.14978798324229 42.14510741555582 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_15_1" type="yellow" pose="42.5254982243 40.7156847956 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_16" type="yellow" pose="43.90120846536342 39.286262175708316 0.15 0 0 0"/>
       <xacro:cone name="yellow_17" type="yellow" pose="44.90826556820963 37.5755857208311 0.15 0 0 0"/>
       <xacro:cone name="yellow_18" type="yellow" pose="45.6770516867903 35.7457093874421 0.15 0 0 0"/>
       <xacro:cone name="yellow_19" type="yellow" pose="46.22275966554793 33.81178351060235 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_19_1" type="yellow" pose="46.3910603595 31.8007765258 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_20" type="yellow" pose="46.559361053395975 29.789769541058664 0.15 0 0 0"/>
       <xacro:cone name="yellow_21" type="yellow" pose="46.30743488318615 27.78237259622894 0.15 0 0 0"/>
@@ -47,5 +52,7 @@
       <xacro:cone name="yellow_23" type="yellow" pose="44.908548622556765 24.010952043673313 0.15 0 0 0"/>
       <xacro:cone name="yellow_24" type="yellow" pose="43.806954990849555 22.35769184894132 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_24_1" type="yellow" pose="42.4013855461 20.9621730615 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_25" type="yellow" pose="40.99581610144987 19.56665427410431 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_25_1" type="yellow" pose="39.2926227022 18.5079254281 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_26" type="yellow" pose="37.58942930289589 17.449196582091318 0.15 0 0 0"/>
       <xacro:cone name="yellow_27" type="yellow" pose="35.724485258381534 16.68177846855147 0.15 0 0 0"/>
@@ -55,5 +62,7 @@
       <xacro:cone name="yellow_31" type="yellow" pose="27.79541989221915 16.00782710654839 0.15 0 0 0"/>
       <xacro:cone name="yellow_32" type="yellow" pose="25.852849227498712 16.444569038841298 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_32_1" type="yellow" pose="24.0019032861 17.1685754879 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_33" type="yellow" pose="22.15095734467817 17.89258193695824 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_33_1" type="yellow" pose="20.4539338156 18.8923245080 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_34" type="yellow" pose="18.756910286540602 19.892067078945477 0.15 0 0 0"/>
       <xacro:cone name="yellow_35" type="yellow" pose="17.142986415793285 20.99897830852109 0.15 0 0 0"/>
@@ -61,10 +70,13 @@
       <xacro:cone name="yellow_37" type="yellow" pose="13.932100997968538 23.21409038636849 0.15 0 0 0"/>
       <xacro:cone name="yellow_38" type="yellow" pose="12.2786209937283 24.23446369835406 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_38_1" type="yellow" pose="10.5052122700 25.0602268423 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_39" type="yellow" pose="8.731803546215698 25.885989986161412 0.15 0 0 0"/>
       <xacro:cone name="yellow_40" type="yellow" pose="6.832823483875245 26.454378591868764 0.15 0 0 0"/>
       <xacro:cone name="yellow_41" type="yellow" pose="4.887048751760895 26.83615571265196 0.15 0 0 0"/>
       <xacro:cone name="yellow_42" type="yellow" pose="2.913404638138635 27.033913423532894 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_42_1" type="yellow" pose="0.9679953347 26.9655055275 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_43" type="yellow" pose="-0.9774139688039005 26.897097631462337 0.15 0 0 0"/>
       <xacro:cone name="yellow_44" type="yellow" pose="-2.8247361400201005 26.51822233676634 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_44_1" type="yellow" pose="-4.4857095475 25.6601171234 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_45" type="yellow" pose="-6.146682954948857 24.802011910051263 0.15 0 0 0"/>
       <xacro:cone name="yellow_46" type="yellow" pose="-7.435776835160203 23.347703328000172 0.15 0 0 0"/>
@@ -74,4 +86,6 @@
       <xacro:cone name="yellow_50" type="yellow" pose="-7.906907189430726 15.894288978520839 0.15 0 0 0"/>
       <xacro:cone name="yellow_51" type="yellow" pose="-6.810632994311648 14.229047936083088 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_51_1" type="yellow" pose="-5.1357383969 12.9851605577 0.1500000000 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_51_2" type="yellow" pose="-3.4608437995 11.7412731794 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_52" type="yellow" pose="-1.7859492021266923 10.49738580102239 0.15 0 0 0"/>
       <xacro:cone name="yellow_53" type="yellow" pose="-0.00012428232300321085 9.353599940485795 0.15 0 0 0"/>
@@ -80,10 +94,13 @@
       <xacro:cone name="yellow_56" type="yellow" pose="3.8389712366925814 4.56016591136155 0.15 0 0 0"/>
       <xacro:cone name="yellow_57" type="yellow" pose="4.262490063294637 2.7673286003135065 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_57_1" type="yellow" pose="4.4629285348 0.9554136428 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_58" type="yellow" pose="4.663367006335313 -0.8565013146841276 0.15 0 0 0"/>
       <xacro:cone name="yellow_59" type="yellow" pose="4.977015403897706 -2.6187430979169424 0.15 0 0 0"/>
       <xacro:cone name="yellow_60" type="yellow" pose="5.618316248357477 -4.325717188610818 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_60_1" type="yellow" pose="7.0065334015 -5.7616477655 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_61" type="yellow" pose="8.394750554704155 -7.197578342421847 0.15 0 0 0"/>
       <xacro:cone name="yellow_62" type="yellow" pose="10.22400431419334 -8.100065262765193 0.15 0 0 0"/>
       <xacro:cone name="yellow_63" type="yellow" pose="12.182179386685789 -8.711377971456416 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_63_1" type="yellow" pose="14.2142341636 -9.0839646257 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_64" type="yellow" pose="16.246288940438234 -9.45655127990549 0.15 0 0 0"/>
       <xacro:cone name="yellow_65" type="yellow" pose="18.27883333804985 -9.809885434048372 0.15 0 0 0"/>
@@ -92,4 +109,6 @@
       <xacro:cone name="yellow_68" type="yellow" pose="24.051424223031407 -11.387872382470654 0.15 0 0 0"/>
       <xacro:cone name="yellow_69" type="yellow" pose="25.918958042846732 -12.082754414653754 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_69_1" type="yellow" pose="27.7373688934 -12.8959750814 0.1500000000 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_69_2" type="yellow" pose="29.5557797439 -13.7091957482 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_70" type="yellow" pose="31.374190594453413 -14.522416414918386 0.15 0 0 0"/>
       <xacro:cone name="yellow_71" type="yellow" pose="33.19811016657506 -15.46498030543914 0.15 0 0 0"/>
@@ -99,10 +118,13 @@
       <xacro:cone name="yellow_75" type="yellow" pose="39.10618161961696 -21.07629741828766 0.15 0 0 0"/>
       <xacro:cone name="yellow_76" type="yellow" pose="39.74118751699343 -22.961867601726045 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_76_1" type="yellow" pose="39.7834863482 -24.9397075227 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_77" type="yellow" pose="39.82578517945869 -26.91754744370056 0.15 0 0 0"/>
       <xacro:cone name="yellow_78" type="yellow" pose="39.33300483741739 -28.842528794938666 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_78_1" type="yellow" pose="38.3859991525 -30.6091692607 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_79" type="yellow" pose="37.43899346750514 -32.37580972646019 0.15 0 0 0"/>
       <xacro:cone name="yellow_80" type="yellow" pose="36.07263514112005 -33.87464656152243 0.15 0 0 0"/>
       <xacro:cone name="yellow_81" type="yellow" pose="34.46005335657848 -35.104994889282885 0.15 0 0 0"/>
       <xacro:cone name="yellow_82" type="yellow" pose="32.65199646808223 -36.002093459407604 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_82_1" type="yellow" pose="30.7448965667 -36.4014189837 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_83" type="yellow" pose="28.837796665385806 -36.80074450806187 0.15 0 0 0"/>
       <xacro:cone name="yellow_84" type="yellow" pose="26.893310732581536 -36.84420143818501 0.15 0 0 0"/>
@@ -110,5 +132,7 @@
       <xacro:cone name="yellow_86" type="yellow" pose="23.02648378304012 -36.59569720318534 0.15 0 0 0"/>
       <xacro:cone name="yellow_87" type="yellow" pose="21.08798856588526 -36.456202179343975 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_87_1" type="yellow" pose="19.0743683884 -36.4005212999 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_88" type="yellow" pose="17.060748210827835 -36.34484042040226 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_88_1" type="yellow" pose="15.0366743971 -36.3227139318 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_89" type="yellow" pose="13.012600583372173 -36.300587443169924 0.15 0 0 0"/>
       <xacro:cone name="yellow_90" type="yellow" pose="10.986708199955569 -36.2093133738479 0.15 0 0 0"/>
@@ -118,5 +142,7 @@
       <xacro:cone name="yellow_94" type="yellow" pose="3.1459249932399747 -34.72189157826258 0.15 0 0 0"/>
       <xacro:cone name="yellow_95" type="yellow" pose="1.2691116882411617 -34.11095644625483 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_95_1" type="yellow" pose="-0.6053845337 -33.4492056832 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_96" type="yellow" pose="-2.479880755615443 -32.787454920112495 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_96_1" type="yellow" pose="-4.3571648338 -32.0779838641 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_97" type="yellow" pose="-6.234448912075027 -31.368512808159238 0.15 0 0 0"/>
       <xacro:cone name="yellow_98" type="yellow" pose="-8.091445603362835 -30.603922716097355 0.15 0 0 0"/>
@@ -124,10 +150,13 @@
       <xacro:cone name="yellow_100" type="yellow" pose="-11.721764699738086 -28.91944080656109 0.15 0 0 0"/>
       <xacro:cone name="yellow_101" type="yellow" pose="-13.48644538341973 -28.003030787640718 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_101_1" type="yellow" pose="-15.2216157815 -27.0351069583 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_102" type="yellow" pose="-16.956786179642428 -26.067183128911022 0.15 0 0 0"/>
       <xacro:cone name="yellow_103" type="yellow" pose="-18.675187763719165 -25.072818951988154 0.15 0 0 0"/>
       <xacro:cone name="yellow_104" type="yellow" pose="-20.40151619507128 -24.070526680166758 0.15 0 0 0"/>
       <xacro:cone name="yellow_105" type="yellow" pose="-22.140725150728972 -23.049560467846955 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_105_1" type="yellow" pose="-23.8506045010 -21.9745857060 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_106" type="yellow" pose="-25.56048385123042 -20.89961094410251 0.15 0 0 0"/>
       <xacro:cone name="yellow_107" type="yellow" pose="-27.207020328980782 -19.725123573768403 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_107_1" type="yellow" pose="-28.7375475934 -18.4016168622 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_108" type="yellow" pose="-30.26807485778629 -17.078110150691657 0.15 0 0 0"/>
       <xacro:cone name="yellow_109" type="yellow" pose="-31.62479918415869 -15.583306472866171 0.15 0 0 0"/>
@@ -137,4 +166,6 @@
       <xacro:cone name="yellow_113" type="yellow" pose="-35.58415446156753 -8.675250961797948 0.15 0 0 0"/>
       <xacro:cone name="yellow_114" type="yellow" pose="-36.21905634131587 -6.780887141720483 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_114_1" type="yellow" pose="-36.6010963154 -4.8292427582 0.1500000000 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_114_2" type="yellow" pose="-36.9831362895 -2.8775983747 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_115" type="yellow" pose="-37.36517626358668 -0.9259539911326335 0.15 0 0 0"/>
       <xacro:cone name="yellow_116" type="yellow" pose="-37.545136013999645 1.0524599719575263 0.15 0 0 0"/>
@@ -143,10 +174,13 @@
       <xacro:cone name="yellow_119" type="yellow" pose="-37.737887451347056 7.000362448051455 0.15 0 0 0"/>
       <xacro:cone name="yellow_120" type="yellow" pose="-37.74957972703662 8.981623114552809 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_120_1" type="yellow" pose="-37.7683514877 10.9763210390 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_121" type="yellow" pose="-37.78712324843369 12.971018963408433 0.15 0 0 0"/>
       <xacro:cone name="yellow_122" type="yellow" pose="-37.81460927637814 14.969323379686614 0.15 0 0 0"/>
       <xacro:cone name="yellow_123" type="yellow" pose="-37.84257163002287 16.967966684837315 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_123_1" type="yellow" pose="-37.8621975322 18.9672160460 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_124" type="yellow" pose="-37.88182343431758 20.96646540707266 0.15 0 0 0"/>
       <xacro:cone name="yellow_125" type="yellow" pose="-37.88405546152681 22.96631898267534 0.15 0 0 0"/>
       <xacro:cone name="yellow_126" type="yellow" pose="-37.86864964327135 24.966446219020604 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_126_1" type="yellow" pose="-37.7777484067 27.0235149146 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_127" type="yellow" pose="-37.68684717013585 29.08058361022998 0.15 0 0 0"/>
       <xacro:cone name="yellow_128" type="yellow" pose="-37.34365493802 31.14111291432141 0.15 0 0 0"/>
@@ -155,7 +189,8 @@
       <xacro:cone name="yellow_131" type="yellow" pose="-34.171512538748246 36.32252142211884 0.15 0 0 0"/>
       <xacro:cone name="yellow_132" type="yellow" pose="-32.637887887516726 37.309180662540584 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_132_1" type="yellow" pose="-30.9770010283 38.1478731937 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_133" type="yellow" pose="-29.316114169093105 38.98656572482106 0.15 0 0 0"/>
       <xacro:cone name="yellow_134" type="yellow" pose="-27.528072554880104 39.96993058576901 0.15 0 0 0"/>
-      <xacro:cone name="yellow_134_1" type="yellow" pose="-26.1395 39.6973 0.15 0 0 0"/>
+      <xacro:cone name="yellow_134_1" type="yellow" pose="-25.95 40.71 0.15 0 0 0"/>
         <xacro:cone name="yellow_134_2" type="yellow" pose="-24.43299 41.6273 0.15 0 0 0"/>
       <xacro:cone name="yellow_135" type="yellow" pose="-22.143865377879276 42.89700866842411 0.15 0 0 0"/>
@@ -165,10 +200,13 @@
       <xacro:cone name="yellow_139" type="yellow" pose="-14.388739865239039 44.792060352630735 0.15 0 0 0"/>
       <xacro:cone name="yellow_140" type="yellow" pose="-12.446156798567005 44.81093954708601 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_140_1" type="yellow" pose="-10.4866459657 44.7632736531 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_141" type="yellow" pose="-8.527135132916301 44.71560775917582 0.15 0 0 0"/>
       <xacro:cone name="yellow_142" type="yellow" pose="-6.5317652114187235 44.685196677088854 0.15 0 0 0"/>
       <xacro:cone name="yellow_143" type="yellow" pose="-4.535958706218395 44.67652168863474 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_143_1" type="yellow" pose="-2.5399010344 44.6948753201 0.1500000000 0 0 0"/>
       <xacro:cone name="yellow_144" type="yellow" pose="-0.5438433625745582 44.7132289515476 0.15 0 0 0"/>
       <xacro:cone name="yellow_145" type="yellow" pose="1.4522487749088362 44.75303019759575 0.15 0 0 0"/>
       <xacro:cone name="yellow_146" type="yellow" pose="3.448320708384206 44.803407571249004 0.15 0 0 0"/>
+      <xacro:cone name="yellow_gap_after_yellow_146_1" type="yellow" pose="5.4444998029 44.8640410733 0.1500000000 0 0 0"/>
       <xacro:cone name="large_orange_2" type="large_orange" pose="8.29483356036796 47.8005083348189 0.15 0 0 0"/>
       <xacro:cone name="blue_2" type="blue" pose="10.2903642978411 47.8659036790991 0.15 0 0 0"/>
@@ -177,4 +215,6 @@
       <xacro:cone name="blue_5" type="blue" pose="16.3042155724446 48.0371512121282 0.15 0 0 0"/>
       <xacro:cone name="blue_6" type="blue" pose="18.318112860148 48.0759783968909 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_6_1" type="blue" pose="20.3411485375 48.0824429167 0.1500000000 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_6_2" type="blue" pose="22.3641842148 48.0889074366 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_7" type="blue" pose="24.3872198920862 48.0953719564451 0.15 0 0 0"/>
       <xacro:cone name="blue_8" type="blue" pose="26.4188343006777 48.0592693339474 0.15 0 0 0"/>
@@ -184,10 +224,13 @@
       <xacro:cone name="blue_12" type="blue" pose="34.7354354110013 47.5303707137414 0.15 0 0 0"/>
       <xacro:cone name="blue_13" type="blue" pose="36.9671887094624 47.1090924863221 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_13_1" type="blue" pose="39.2139985805 46.2484860542 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_14" type="blue" pose="41.4608084515852 45.3878796220444 0.15 0 0 0"/>
       <xacro:cone name="blue_15" type="blue" pose="43.5486168233166 43.9466679046951 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_15_1" type="blue" pose="45.1561969037 42.0652694172 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_16" type="blue" pose="46.7637769841785 40.1838709296144 0.15 0 0 0"/>
       <xacro:cone name="blue_17" type="blue" pose="47.8711744070693 38.045874156376 0.15 0 0 0"/>
       <xacro:cone name="blue_18" type="blue" pose="48.6759026786991 35.8287318442088 0.15 0 0 0"/>
       <xacro:cone name="blue_19" type="blue" pose="49.2095764033813 33.5308461962448 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_19_1" type="blue" pose="49.2906835315 31.1382351462 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_20" type="blue" pose="49.371790659603 28.7456240961468 0.15 0 0 0"/>
       <xacro:cone name="blue_21" type="blue" pose="48.9402528124274 26.3442245678724 0.15 0 0 0"/>
@@ -195,5 +238,7 @@
       <xacro:cone name="blue_23" type="blue" pose="46.9718766730536 21.8331831495909 0.15 0 0 0"/>
       <xacro:cone name="blue_24" type="blue" pose="45.5183908761479 19.8937545099424 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_24_1" type="blue" pose="43.7764215802 18.3229699695 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_25" type="blue" pose="42.034452284309 16.7521854290723 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_25_1" type="blue" pose="40.0184391992 15.6149728599 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_26" type="blue" pose="38.0024261140352 14.4777602906678 0.15 0 0 0"/>
       <xacro:cone name="blue_27" type="blue" pose="35.7974585974047 13.6826661179064 0.15 0 0 0"/>
@@ -203,5 +248,7 @@
       <xacro:cone name="blue_31" type="blue" pose="26.4275819814214 13.3378047377686 0.15 0 0 0"/>
       <xacro:cone name="blue_32" type="blue" pose="24.1935407090117 13.9452300781406 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_32_1" type="blue" pose="22.1205700514 14.8493400523 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_33" type="blue" pose="20.0475993937396 15.7534500265274 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_33_1" type="blue" pose="18.2213925877 16.8977913421 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_34" type="blue" pose="16.395185781583 18.0421326577611 0.15 0 0 0"/>
       <xacro:cone name="blue_35" type="blue" pose="14.7344934919394 19.210358215895 0.15 0 0 0"/>
@@ -209,8 +256,10 @@
       <xacro:cone name="blue_37" type="blue" pose="11.5833537070008 21.3477072094266 0.15 0 0 0"/>
       <xacro:cone name="blue_38" type="blue" pose="10.0428032559345 22.2341839570762 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_38_1" type="blue" pose="8.4714360723 22.8721530357 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_39" type="blue" pose="6.90006888859156 23.510122114402 0.15 0 0 0"/>
       <xacro:cone name="blue_40" type="blue" pose="5.24310276950825 23.9102111346615 0.15 0 0 0"/>
       <xacro:cone name="blue_41" type="blue" pose="3.54614319085073 24.1525066527486 0.15 0 0 0"/>
       <xacro:cone name="blue_42" type="blue" pose="1.82453456285617 24.2384953941222 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_42_1" type="blue" pose="0.1640323464 24.0904186861 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_43" type="blue" pose="-1.49646987010121 23.9423419780574 0.15 0 0 0"/>
       <xacro:cone name="blue_44" type="blue" pose="-2.88611819700968 23.518850361989 0.15 0 0 0"/>
@@ -222,4 +271,6 @@
       <xacro:cone name="blue_50" type="blue" pose="-4.95012865665813 16.4016948398736 0.15 0 0 0"/>
       <xacro:cone name="blue_51" type="blue" pose="-4.05317915721677 15.4107620877673 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_51_1" type="blue" pose="-2.5380789271 14.4236443198 0.1500000000 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_51_2" type="blue" pose="-1.0229786970 13.4365265518 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_52" type="blue" pose="0.49212153312725 12.4494087837712 0.15 0 0 0"/>
       <xacro:cone name="blue_53" type="blue" pose="2.38653784056378 11.1712478467585 0.15 0 0 0"/>
@@ -228,4 +279,5 @@
       <xacro:cone name="blue_56" type="blue" pose="6.83628597561633 4.68706884998182 0.15 0 0 0"/>
       <xacro:cone name="blue_57" type="blue" pose="7.22868549746256 2.31823546262226 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_57_1" type="blue" pose="7.4191844519 0.4483694321 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_58" type="blue" pose="7.60968340642873 -1.42149659832866 0.15 0 0 0"/>
       <xacro:cone name="blue_59" type="blue" pose="7.9750905618407 -2.7261923758349 0.15 0 0 0"/>
@@ -234,4 +286,5 @@
       <xacro:cone name="blue_62" type="blue" pose="12.1167992046948 -5.77254995615783 0.15 0 0 0"/>
       <xacro:cone name="blue_63" type="blue" pose="13.7805173778787 -6.17261534649334 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_63_1" type="blue" pose="15.7018131479 -6.4818824138 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_64" type="blue" pose="17.6231089179688 -6.79114948102549 0.15 0 0 0"/>
       <xacro:cone name="blue_65" type="blue" pose="19.7388585053217 -7.18913620702706 0.15 0 0 0"/>
@@ -240,4 +293,6 @@
       <xacro:cone name="blue_68" type="blue" pose="25.8797524901441 -9.00938215804746 0.15 0 0 0"/>
       <xacro:cone name="blue_69" type="blue" pose="27.8385154732156 -9.77726113305095 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_69_1" type="blue" pose="29.7199655246 -10.6476826536 0.1500000000 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_69_2" type="blue" pose="31.6014155759 -11.5181041741 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_70" type="blue" pose="33.4828656272925 -12.388525694689 0.15 0 0 0"/>
       <xacro:cone name="blue_71" type="blue" pose="35.3884273243004 -13.4149776838374 0.15 0 0 0"/>
@@ -247,10 +302,14 @@
       <xacro:cone name="blue_75" type="blue" pose="42.0705518955054 -20.6153105774461 0.15 0 0 0"/>
       <xacro:cone name="blue_76" type="blue" pose="42.7346589897432 -23.1596769590206 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_76_1" type="blue" pose="42.6613419726 -24.8557333245 0.1500000000 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_76_2" type="blue" pose="42.5880249555 -26.5517896899 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_77" type="blue" pose="42.5147079384368 -28.247846055385 0.15 0 0 0"/>
       <xacro:cone name="blue_78" type="blue" pose="41.753803677142 -30.6144579632713 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_78_1" type="blue" pose="40.4684610106 -32.7155874916 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_79" type="blue" pose="39.1831183440142 -34.8167170198948 0.15 0 0 0"/>
       <xacro:cone name="blue_80" type="blue" pose="37.3770559671547 -36.5762176430613 0.15 0 0 0"/>
       <xacro:cone name="blue_81" type="blue" pose="35.2523671945937 -37.9984770098583 0.15 0 0 0"/>
       <xacro:cone name="blue_82" type="blue" pose="32.8791324240351 -38.993482644638 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_82_1" type="blue" pose="30.5030920146 -39.3544091417 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_83" type="blue" pose="28.1270516052592 -39.715335638822 0.15 0 0 0"/>
       <xacro:cone name="blue_84" type="blue" pose="25.9046030197368 -39.6765956654354 0.15 0 0 0"/>
@@ -258,5 +317,7 @@
       <xacro:cone name="blue_86" type="blue" pose="21.8464792201864 -39.3538830619781 0.15 0 0 0"/>
       <xacro:cone name="blue_87" type="blue" pose="19.9742827992146 -39.2418187116909 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_87_1" type="blue" pose="18.0340156215 -39.2132689530 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_88" type="blue" pose="16.0937484438592 -39.1847191943436 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_88_1" type="blue" pose="14.0432865432 -39.1533319702 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_89" type="blue" pose="11.9928246424488 -39.1219447460144 0.15 0 0 0"/>
       <xacro:cone name="blue_90" type="blue" pose="9.86352410414552 -38.9911216862446 0.15 0 0 0"/>
@@ -266,5 +327,7 @@
       <xacro:cone name="blue_94" type="blue" pose="1.40682879137184 -37.1663842455962 0.15 0 0 0"/>
       <xacro:cone name="blue_95" type="blue" pose="-0.541821138011257 -36.5027177844325 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_95_1" type="blue" pose="-2.4409886747 -35.8218802200 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_96" type="blue" pose="-4.34015621146816 -35.1410426555394 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_96_1" type="blue" pose="-6.2522581063 -34.4031943797 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_97" type="blue" pose="-8.16436000121084 -33.6653461038145 0.15 0 0 0"/>
       <xacro:cone name="blue_98" type="blue" pose="-10.0767778404464 -32.8530238495275 0.15 0 0 0"/>
@@ -272,10 +335,13 @@
       <xacro:cone name="blue_100" type="blue" pose="-13.8428086034457 -31.0410375539532 0.15 0 0 0"/>
       <xacro:cone name="blue_101" type="blue" pose="-15.6623928384561 -30.0682796038662 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_101_1" type="blue" pose="-17.4291002823 -29.0660778135 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_102" type="blue" pose="-19.1958077261686 -28.0638760232219 0.15 0 0 0"/>
       <xacro:cone name="blue_103" type="blue" pose="-20.9238240938196 -27.0586776214187 0.15 0 0 0"/>
       <xacro:cone name="blue_104" type="blue" pose="-22.6524765196268 -26.0537507263292 0.15 0 0 0"/>
       <xacro:cone name="blue_105" type="blue" pose="-24.4077080359509 -25.0144494209715 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_105_1" type="blue" pose="-26.1718930618 -23.8730749446 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_106" type="blue" pose="-27.9360780875981 -22.7317004681533 0.15 0 0 0"/>
       <xacro:cone name="blue_107" type="blue" pose="-29.6698538901663 -21.4381474644069 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_107_1" type="blue" pose="-31.3076051552 -19.9349159667 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_108" type="blue" pose="-32.9453564203185 -18.4316844689044 0.15 0 0 0"/>
       <xacro:cone name="blue_109" type="blue" pose="-34.4107565227371 -16.6961594315364 0.15 0 0 0"/>
@@ -285,4 +351,6 @@
       <xacro:cone name="blue_113" type="blue" pose="-38.5811746376266 -8.808929921604 0.15 0 0 0"/>
       <xacro:cone name="blue_114" type="blue" pose="-39.2178699842561 -6.69652639898087 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_114_1" type="blue" pose="-39.5789735675 -4.5675548515 0.1500000000 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_114_2" type="blue" pose="-39.9400771507 -2.4385833041 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_115" type="blue" pose="-40.3011807339499 -0.309611756649864 0.15 0 0 0"/>
       <xacro:cone name="blue_116" type="blue" pose="-40.4533406202231 1.78890139416343 0.15 0 0 0"/>
@@ -291,10 +359,13 @@
       <xacro:cone name="blue_119" type="blue" pose="-40.5919497511314 7.92466131148779 0.15 0 0 0"/>
       <xacro:cone name="blue_120" type="blue" pose="-40.6014196538181 9.91275631233656 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_120_1" type="blue" pose="-40.6235876914 11.8969206974 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_121" type="blue" pose="-40.6457557289961 13.8810850824754 0.15 0 0 0"/>
       <xacro:cone name="blue_122" type="blue" pose="-40.674533449872 15.8753221224371 0.15 0 0 0"/>
       <xacro:cone name="blue_123" type="blue" pose="-40.7017394704418 17.8763494567535 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_123_1" type="blue" pose="-40.7174829445 19.8876426251 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_124" type="blue" pose="-40.7332264185658 21.898935793423 0.15 0 0 0"/>
       <xacro:cone name="blue_125" type="blue" pose="-40.7282871101318 23.9204396925825 0.15 0 0 0"/>
       <xacro:cone name="blue_126" type="blue" pose="-40.7033369152928 25.948560300907 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_126_1" type="blue" pose="-40.5662486611 28.1227902781 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_127" type="blue" pose="-40.429160406945 30.2970202551981 0.15 0 0 0"/>
       <xacro:cone name="blue_128" type="blue" pose="-39.9260632680985 32.6679289532538 0.15 0 0 0"/>
@@ -303,6 +374,9 @@
       <xacro:cone name="blue_131" type="blue" pose="-35.2924298638551 39.105243893059 0.15 0 0 0"/>
       <xacro:cone name="blue_132" type="blue" pose="-33.2056190082383 40.2549711124138 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_132_1" type="blue" pose="-31.4996008387 41.1016485481 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_133" type="blue" pose="-29.7935826692359 41.9483259837501 0.15 0 0 0"/>
       <xacro:cone name="blue_134" type="blue" pose="-28.1179159337869 42.9113732230407 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_134_1" type="blue" pose="-26.2413626119 43.8999740255 0.1500000000 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_134_2" type="blue" pose="-24.3648092900 44.8885748280 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_135" type="blue" pose="-22.4882559681602 45.8771756304123 0.15 0 0 0"/>
       <xacro:cone name="blue_136" type="blue" pose="-20.3655683666973 46.6715497668858 0.15 0 0 0"/>
@@ -311,10 +385,13 @@
       <xacro:cone name="blue_139" type="blue" pose="-13.5681633690504 47.6776546092619 0.15 0 0 0"/>
       <xacro:cone name="blue_140" type="blue" pose="-11.464425411051 47.6457593795914 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_140_1" type="blue" pose="-9.4921555793 47.5936103789 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_141" type="blue" pose="-7.51988574761303 47.5414613781388 0.15 0 0 0"/>
       <xacro:cone name="blue_142" type="blue" pose="-5.55737846449435 47.5225493988029 0.15 0 0 0"/>
       <xacro:cone name="blue_143" type="blue" pose="-3.5905890292448 47.5236739806379 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_143_1" type="blue" pose="-1.6176956014 47.5495109460 0.1500000000 0 0 0"/>
       <xacro:cone name="blue_144" type="blue" pose="0.355197826404633 47.5753479114301 0.15 0 0 0"/>
       <xacro:cone name="blue_145" type="blue" pose="2.33404449770947 47.6205092826547 0.15 0 0 0"/>
       <xacro:cone name="blue_146" type="blue" pose="4.31684977705784 47.6749328204622 0.15 0 0 0"/>
+      <xacro:cone name="blue_gap_after_blue_146_1" type="blue" pose="6.3058416687 47.7377205776 0.1500000000 0 0 0"/>
       <plugin name="gz::sim::systems::PosePublisher" filename="gz-sim-pose-publisher-system">
         <use_pose_vector_msg>true</use_pose_vector_msg>
